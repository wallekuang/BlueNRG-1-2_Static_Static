# Keil uVision project BLE_Static_Stack.uvprojx, settings and files
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: IROM(0x10040000,0x40000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLE_Static_Stack +hex
  AfterMake: fromelf.exe --bin Release\Objects\BLE_Static_Stack.axf --output Release\Objects\BLE_Static_Stack.bin
  AfterMake: ..\..\..\..\..\Utility\create_sym_lib.exe --symbols ..\..\sym_export.txt --rename BlueNRG_Stack_Initialization=BlueNRG_Stack_Initialization_nocallbacks Release\Objects\BLE_Static_Stack.axf ..\..\..\..\..\Library\Bluetooth_LE\library\static_stack\libbluenrg2_static_stack.a
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: SMPS_INDUCTOR=SMPS_INDUCTOR_10uH BLUENRG2_DEVICE APP_OFFSET=0x1B000 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION
  c include: ..\..\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\hal\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\Bluetooth_LE\library\static_stack
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_SIZE=0x1B000"
  group BlueNRG1_Periph_Driver
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_flash.c BlueNRG1_pka.c BlueNRG1_sysCtrl.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: bluenrg1_cmd_if.c bluenrg1_ev_if.c bluenrg1_it_stub.c Reset_Manager.c OTA_ResetManager_main.c
  group Hal
    ../../../../../Library/hal/src/: context_switch.s osal.c miscutil.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
    ../../../../../Library/cryptolib/: libcrypto.a
target OTA_BTL_ResetManager (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: BLE_Static_Stack_OTA_BTL_ResetManager +hex
  AfterMake: fromelf.exe --bin OTA_BTL_ResetManager\Objects\BLE_Static_Stack_OTA_BTL_ResetManager.axf --output OTA_BTL_ResetManager\Objects\BLE_Static_Stack_OTA_BTL_ResetManager.bin
  AfterMake: ..\..\..\..\..\Utility\create_sym_lib.exe --symbols ..\..\sym_export.txt --rename BlueNRG_Stack_Initialization=BlueNRG_Stack_Initialization_nocallbacks OTA_BTL_ResetManager\Objects\BLE_Static_Stack_OTA_BTL_ResetManager.axf OTA_BTL_ResetManager\libbluenrg2_static_stack_with_resetmanager.a
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: BLUENRG2_DEVICE RESET_MANAGER_SIZE=0x1B800 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION
  c include: ..\..\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\hal\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\BLE_Application\OTA\inc;..\..\..\..\..\Library\Bluetooth_LE\library\static_stack
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_SIZE=0x1B800"
