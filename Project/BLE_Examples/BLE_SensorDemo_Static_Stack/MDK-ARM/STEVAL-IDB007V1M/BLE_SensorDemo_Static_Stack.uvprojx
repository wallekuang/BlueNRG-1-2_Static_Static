# Keil uVision project BLE_SensorDemo_Static_Stack.uvprojx, settings and files
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x10040000,0x28000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLE_SensorDemo_Static_Stack +hex
  AfterMake: fromelf.exe --bin Release\Objects\BLE_SensorDemo_Static_Stack.axf --output Release\Objects\BLE_SensorDemo_Static_Stack.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USER_BUTTON=BUTTON_2 HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH NO_SMART_POWER_MANAGEMENT BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION
  c include: ..\..\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\hal\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\BLE_Application\layers_inc;..\..\..\..\..\Library\BLE_Application\Utils\inc;..\..\..\..\..\Library\BLE_Application\OTA\inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=0x1A800 -DMEMORY_RAM_APP_OFFSET=0x0460"
  group BlueNRG1_Periph_Driver
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c BlueNRG1_pka.c
  group Platforms_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Com.c SDK_EVAL_Config.c LPS25HB.c LSM6DS3.c SDK_EVAL_Button.c SDK_EVAL_I2C.c SDK_EVAL_Led.c SDK_EVAL_SPI.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: BlueNRG1_it.c gatt_db.c sensor.c SensorDemo_main.c
    ../../../../../Library/Bluetooth_LE/library/static_stack/: bluenrg1_stack_init_if.c
  group Hal
    ../../../../../Library/hal/src/: osal.c sleep.c context_switch.s clock.c miscutil.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/static_stack/: libbluenrg1_static_stack.a libbluenrg1_static_stack_with_resetmanager.a
  group OTA_BTL
    ../../../../../Library/BLE_Application/OTA/src/: OTA_btl.c
target LowerApp_OTA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: as above
  output: BLE_SensorDemo_Static_Stack_LowerApp_OTA +hex
  AfterMake: fromelf.exe --bin LowerApp_OTA\Objects\BLE_SensorDemo_Static_Stack_LowerApp_OTA.axf --output LowerApp_OTA\Objects\BLE_SensorDemo_Static_Stack_LowerApp_OTA.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: ST_OTA_LOWER_APPLICATION=1 RESET_MANAGER_SIZE=0x1A800 HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH NO_SMART_POWER_MANAGEMENT BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  link misc: --predefine="-DST_OTA_LOWER_APPLICATION=1 -DRESET_MANAGER_SIZE=0x1A800 -DMEMORY_RAM_APP_OFFSET=0x0460"
target HigherApp_OTA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: IROM(0x10040000,0x40000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLE_SensorDemo_HigherApp_OTA +hex
  AfterMake: fromelf.exe --bin HigherApp_OTA\Objects\BLE_SensorDemo_HigherApp_OTA.axf --output HigherApp_OTA\Objects\BLE_SensorDemo_HigherApp_OTA.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: ST_OTA_HIGHER_APPLICATION=1 RESET_MANAGER_SIZE=0x1A800 HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH NO_SMART_POWER_MANAGEMENT BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  link misc: --predefine="-DST_OTA_HIGHER_APPLICATION=1 -DRESET_MANAGER_SIZE=0x1A800 -DMEMORY_RAM_APP_OFFSET=0x0460"
